## tests/runner/example/testcase.yaml
```yaml
common:
  platform_allow:
    - custom_plank
  integration_platforms:
    - custom_plank
  harness: ctest
tests:
  runner.example: {}
```
